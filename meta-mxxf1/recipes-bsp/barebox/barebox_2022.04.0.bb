require barebox.inc

SRC_URI[sha256sum] = "f751b506deb0a5d82682a85cf65e329dd562e48ea057533dc5c8876120a09ebc"
